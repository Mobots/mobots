Commit message: Der Rest, den ich noch gemacht hatte.

File: david_sim/models/01-myfirst.urdf (robot description, URDF)
Before this commit: robot myfirst, 1 links, 0 joints
Links:
- link base_link: geometry visual mesh filename=package://david_sim/models/mobot.stl scale=.1 .1 .1
